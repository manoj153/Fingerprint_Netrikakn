# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\generated\gui_generated\include;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\framework\include;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\board\ST\STM32F746G-DISCO\include;..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include\vendor;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\os\FreeRTOS8.2.0\Source\include;..\..\..\..\..\..\touchgfx\4.8.0\touchgfx\os\FreeRTOS8.2.0\Source\portable\RVDS\ST_CM7
  asm include: .\os\FreeRTOSV8.2.0\FreeRTOS\Source\include;.\os\FreeRTOSV8.2.0\FreeRTOS\Source\portable\RVDS\ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../../../: main.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/Keil/: startup_stm32f746xx.s
  group Gui
    ../../../../gui/src/about_me_screen_screen/: About_Me_ScreenPresenter.cpp About_Me_ScreenView.cpp
    ../../../../gui/src/fingerprint_screen/: FingerPrintPresenter.cpp FingerPrintView.cpp
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group GuiGenerated
    ../../../../generated/gui_generated/src/about_me_screen_screen/: About_Me_ScreenViewBase.cpp
    ../../../../generated/gui_generated/src/fingerprint_screen/: FingerPrintViewBase.cpp
    ../../../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../../../../generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_seguisb_17_4bpp.cpp Font_timesbd_29_4bpp.cpp Font_verdana_11_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_seguisb_17_4bpp.cpp Kerning_timesbd_29_4bpp.cpp Kerning_verdana_11_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_seguisb_17_4bpp.cpp Table_timesbd_29_4bpp.cpp Table_verdana_11_4bpp.cpp Table_verdana_40_4bpp.cpp
    ../../../../generated/images/src/: BitmapDatabase.cpp manoj_png.cpp Under_Construction_PNG.cpp whtasapp_icon_png.cpp
    ../../../../generated/images/src/__designer/: Blue_Buttons_Round_Edge_icon_button_pressed.cpp Blue_Buttons_Round_Edge_small.cpp Blue_Buttons_Round_Edge_small_pressed.cpp Blue_Buttons_Round_icon_button.cpp Blue_Icons_eMail_48.cpp Blue_Icons_News_32.cpp Blue_Icons_User_48.cpp Dark_Icons_Alert_32.cpp Dark_Icons_Back_arrow_32.cpp
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFXHAL
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../../../../../touchgfx/4.8.0/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
