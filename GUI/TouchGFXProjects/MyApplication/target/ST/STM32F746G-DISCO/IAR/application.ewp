# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; C:\touchgfx\4.8.0\touchgfx\framework\include; C:\touchgfx\4.8.0\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; C:\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx; C:\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS; C:\touchgfx\4.8.0\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver; C:\touchgfx\4.8.0\touchgfx\board\ST\STM32F746G-DISCO\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include\vendor; C:\touchgfx\4.8.0\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery; C:\touchgfx\4.8.0\touchgfx\os\FreeRTOS8.2.0\Source\include; C:\touchgfx\4.8.0\touchgfx\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: C:\touchgfx\4.8.0\touchgfx\lib\core\cortex_m7\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_seguisb_17_4bpp.cpp Font_timesbd_29_4bpp.cpp Font_verdana_11_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_seguisb_17_4bpp.cpp Kerning_timesbd_29_4bpp.cpp Kerning_verdana_11_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_seguisb_17_4bpp.cpp Table_timesbd_29_4bpp.cpp Table_verdana_11_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/generated/gui_generated/about_me_screen_screen
    ../../../../generated/gui_generated/src/about_me_screen_screen/: About_Me_ScreenViewBase.cpp
  group Application/generated/gui_generated/common
    ../../../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/screen1_screen
    ../../../../generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp manoj_png.cpp Under_Construction_PNG.cpp whtasapp_icon_png.cpp
  group Application/generated/images/__designer
    ../../../../generated/images/src/__designer/: Blue_Buttons_Round_Edge_icon_button_pressed.cpp Blue_Buttons_Round_Edge_small.cpp Blue_Buttons_Round_Edge_small_pressed.cpp Blue_Buttons_Round_icon_button.cpp Blue_Icons_eMail_48.cpp Blue_Icons_News_32.cpp Blue_Icons_User_48.cpp Dark_Icons_Alert_32.cpp Dark_Icons_Back_arrow_32.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/about_me_screen_screen
    ../../../../gui/src/about_me_screen_screen/: About_Me_ScreenPresenter.cpp About_Me_ScreenView.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/screen1_screen
    ../../../../gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Application/main
    ../../../: main.cpp
  group Board/STM32F746G-DISCO
    C:/touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    C:/touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    C:/touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    C:/touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    C:/touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    C:/touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/IAR/: startup_stm32f746xx.s
    C:/touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    C:/touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    C:/touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    C:/touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    C:/touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
